inherit dpkg-raw

DESCRIPTION = "real-time test suite and tools appropriate for real-time use"

DEBIAN_DEPENDS = " \
    rt-tests \
"
