inherit dpkg-raw

DESCRIPTION = "Update tools used on Phytec boards"

#TODO: implement packages
#DEBIAN_DEPENDS += " \
#    rauc, \
#"
#
