inherit dpkg

SRC_URI = "apt://gnome"
