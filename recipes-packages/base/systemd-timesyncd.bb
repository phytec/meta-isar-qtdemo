inherit dpkg

SRC_URI = "apt://systemd-timesyncd"
