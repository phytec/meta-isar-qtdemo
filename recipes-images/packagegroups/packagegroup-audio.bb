inherit dpkg-raw

DESCRIPTION = "Hardware development tools used on Phytec boards"

DEBIAN_DEPENDS = " \
    alsa-utils, \
    vorbis-tools, \
    libao-dev, \
"
