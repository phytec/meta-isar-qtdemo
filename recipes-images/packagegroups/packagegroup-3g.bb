inherit dpkg-raw

DESCRIPTION = "3g tools used on Phytec boards"

DEBIAN_DEPENDS = " \
    ofono, \
    modemmanager, \
"

